# IAR project PWR_CurrentConsumption.ewp, settings and files
configuration PWR_CurrentConsumption (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F072
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Device\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F072B-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_CurrentConsumption.hex
  ILINK.IlinkOutputFile: PWR_CurrentConsumption.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/Source/Templates/iar/: startup_stm32f072.s
  group STM32F072B_DISCOVERY
    ../../../../Utilities/STM32F072B-Discovery/: stm32f072b_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c
  group User
    ../: main.c stm32f0xx_it.c stm32f0xx_lp_modes.c system_stm32f0xx.c
